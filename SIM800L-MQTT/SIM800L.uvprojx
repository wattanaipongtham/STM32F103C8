# Keil uVision project SIM800L.uvprojx, settings and files
target STM32F103C8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SIM800L
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Inc;.\Src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SIM800L
    ./: main.c
  group Src
    ../../UART/: wattanai_stm32f103c8_clock_config.c
    ./Src/: wattanai_stm32f103c8_uart.c sysTick.c
  group Inc
    ../../UART/: wattanai_stm32f103c8_clock_config.h
    ./Inc/: wattanai_stm32f103c8_uart.h sysTick.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
